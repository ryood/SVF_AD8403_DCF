# Repository ryood/SVF_AD8403_DCF

## EAGLE design eagle/AD8403_SVF/AD8403_SVF.brd

Parts:
C1, C2: 0.01uF; C050-025X075
C3, C4, C5, C6, C7: 0.1uF; C025-024X044
C8, C9: 100uF; E2,5-7
C10: 2.2uF; C050-055X075
IC1: AD8403-DIP24; AD8403_DIP24
IC2, IC3: NJM2732; DIL08
JP1: SPI; 1X04
JP2: PWR; 1X03
JP3: AUDIOIN; 1X02
JP4: LP; 1X02
JP5: BP; 1X02
JP6: HP; 1X02
JP7: VGND; 1X02
JP8: GND; 1X02
LED1, LED2: red; LED3MM
R1: 1k; 0207/7
R2, R3: 10k; 0207/7
R4: 100k; 0207/7
R5: 10k; B25P
R6: 2.2k; 0207/7
R7, R8: 220; 0204V

Connections:
!CS: IC1.11 (!CS), JP1.1
+5V: C3.1, C6.1, C7.1, C8.+, IC1.10 (!SHDN), IC1.15 (!RS), IC1.16 (VDD), IC2.8 (V+), IC3.8 (V+), JP2.1, R7.1
GND: C4.2, C5.2, C7.2, C9.-, IC1.1 (AGND2), IC1.5 (AGND4), IC1.9 (DGND), IC1.17 (AGND3), IC1.21 (AGND1), IC2.4 (V-), IC3.4 (V-), JP1.4, JP2.3, JP3.2, JP4.2, JP5.2, JP6.2, JP8.1, JP8.2, R5.A, R8.1
MOSI: IC1.12 (SDI), JP1.2
unnamed: JP3.1, R5.E
unnamed: C10.1, R5.S
unnamed: IC1.3 (A2), IC1.4 (W2), IC2.3 (+IN), R1.2
unnamed: IC2.2 (-IN), R2.1, R3.1
unnamed: IC1.24 (B1), IC2.1 (OUT), JP6.1, R2.2
unnamed: C2.1, IC1.18 (W3), IC1.19 (A3), IC3.6 (-IN)
unnamed: C1.1, IC1.22 (W1), IC1.23 (A1), IC3.2 (-IN)
unnamed: IC2.6 (-IN), IC2.7 (OUT)
unnamed: C2.2, IC3.7 (OUT), JP4.1, R3.2
unnamed: C1.2, IC1.20 (B3), IC3.1 (OUT), JP5.1, R6.2
unnamed: C10.2, R1.1, R4.2
unnamed: IC1.2 (B2), R6.1
unnamed: LED1.A, R7.2
unnamed: LED2.K (C), R8.2
SCK: IC1.14 (CLK), JP1.3
VCC/2: C3.2, C4.1, C5.1, C6.2, C8.-, C9.+, IC2.5 (+IN), IC3.3 (+IN), IC3.5 (+IN), JP2.2, JP7.1, JP7.2, LED1.K (C), LED2.A, R4.1

Notes on the sheet:
IC2PWR
IC3PWR
ピンソケットで実装

Board: 2 copper layers, 70.8 x 94.0 mm, 31 parts (0 on the bottom side), 20 nets.

## Commit log

2017-04-25 Update: eagle files
2017-05-01 Add: SVF_AD8403 テスト表
2017-05-01 change the output GND from VGND to GND
2017-05-03 Update: schematic pictures
